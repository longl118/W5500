# Keil uVision project http_server.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: http_server +hex
  AfterMake: fromelf.exe --bin --output ./output/http_server.bin ./output/http_server.axf
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: .\User;.\system;.\output;.\flib\inc;.\flib\src;.\word\device;.\word\httpd;.\word\httpult;.\word\md5;.\word\ult;.\word\socket;.\word\spi;.\word\usart;.\word\w5500;.\word\flash
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./User/: main.c stm32f10x_it.c stm32f10x_it.h stm32f10x_conf.h types.h config.h webpge.h
  group system
    ./system/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group flib
    ./flib/src/: misc.c stm32f10x_bkp.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group word
    ./word/flash/: flash.c flash.h
    ./word/device/: device.c device.h
    ./word/httpd/: httpd.c httpd.h
    ./word/httpult/: httpult.c httpult.h
    ./word/md5/: md5.c md5.h
    ./word/socket/: socket.c socket.h
    ./word/spi/: spi2.c spi2.h
    ./word/ult/: ult.c ult.h
    ./word/usart/: usart.c usart.h
    ./word/w5500/: w5500.c w5500.h
